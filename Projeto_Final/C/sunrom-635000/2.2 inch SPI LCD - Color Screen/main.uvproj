# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib
  group Source Group 1
    ./src/: main.c
  group Library
    ../lib/font/: font.c
    ../lib/sys/: sys.c
    ../lib/lcd-2.2/: LCD.c
