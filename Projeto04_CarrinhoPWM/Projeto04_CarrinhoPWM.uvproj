# Keil uVision project Projeto04_CarrinhoPWM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: Projeto04_CarrinhoPWM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Projeto04_CarrinhoPWM.a51 code.c lcd16x2.c pwm.c timer.c teclado_matricial_4x4.c
