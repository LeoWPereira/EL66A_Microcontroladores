# Keil uVision project projeto00_padrao.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: projeto00_padrao
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: projeto00_padrao.a51 timers_and_counters.a51 lcd.a51 teclado_matricial.a51 pwm_com_timer.a51 pwm_com_timer_duty_cycle_por_int.a51
