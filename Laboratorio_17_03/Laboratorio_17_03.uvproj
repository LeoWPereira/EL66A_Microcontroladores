# Keil uVision project Laboratorio_17_03.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: Laboratorio_17_03
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Lab_Ex01.a51 Lab_Ex02.a51 Lab_Ex03.a51 Lab_Ex04.a51
